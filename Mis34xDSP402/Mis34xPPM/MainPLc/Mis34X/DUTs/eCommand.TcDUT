{attribute 'qualified_only'}
{attribute 'strict'}
TYPE eCommand :
(
	Reset := 0,
	Run, 
	Stop
);
END_TYPE
