{attribute 'qualified_only'}
{attribute 'strict'}
TYPE eStatus :
(
	Running := 1,
	CmdOk,
	Done , 
	Error
);
END_TYPE
